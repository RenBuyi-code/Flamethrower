# Keil uVision project Flamethrower.uvprojx, settings and files
target Flamethrower (6230000::V6.23::ARMCLANG)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Flamethrower +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415CBT7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM3;..\..\middleware\RTT\RTT;..\..\middleware\RTT\Config;../../app;../../app/task_safety;../../app/task_control;../../app/task_ui;../../app/task_dmx;../../app/ui_pages;../../bsp/at32f415;../../bsp/st7920;../../bsp/st7920/inc;../../cfg;../../app/rules;../../interfaces;../../middleware/easyDMX;../../middleware/MultiButton;../../middleware/SlateUI/core/inc;../../middleware/SlateUI/widgets/inc;../../middleware/SlateUI/menu/inc;../../middleware/SlateUI/font;../../middleware/SlateUI/port
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c freertos_app.c include_port.c wk_adc.c wk_debug.c wk_usart.c wk_gpio.c
  group cfg
    ../../cfg/: system_config.c system_config.h
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_crm.c at32f415_debug.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_tmr.c at32f415_usart.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group app
    ../../app/: app_fsm.c app_fsm.h app_selftest.c app_selftest.h log_rtt.h app_task_common.c app_task_common.h ui_services.c ui_services.h
  group bsp/at32f415
    ../../bsp/at32f415/: bsp_at32f415.c bsp_at32f415.h bsp_uart.c bsp_uart.h
  group app_rules
    ../../app/rules/: event_log.c event_log.h state_machine.c state_machine.h fault_manager.c fault_manager.h safety_guard.c safety_guard.h dmx_strategy.c dmx_strategy.h
  group bsp/st7920
    ../../bsp/st7920/: at32f415_st7920_port.c at32f415_st7920_port.h
    ../../bsp/st7920/src/: driver_st7920.c driver_st7920.h
  group app/ui_pages
    ../../app/ui_pages/: ui_splash_page.c ui_splash_page.h ui_checking_page.c ui_checking_page.h ui_idle_page.c ui_idle_page.h ui_main_menu.c ui_main_menu.h ui_safety_page.c ui_safety_page.h ui_setting_page.c ui_setting_page.h ui_language_page.c ui_language_page.h
  group app/task_ui
    ../../app/task_ui/: task_ui.c
  group app/task_control
    ../../app/task_control/: task_control.c
  group app/task_safety
    ../../app/task_safety/: task_safety.c
  group app/task_dmx
    ../../app/task_dmx/: task_dmx.c
  group app/task_actuator
    ../../app/task_actuator/: task_actuator.c
  group app/task_diag
    ../../app/task_diag/: task_diag.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group middlewares/segger_rtt
    ../../middleware/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../app/: log_rtt.h
    ../../middleware/RTT/Config/: SEGGER_RTT_Conf.h
  group middleware/ui_input
    ../../middleware/MultiButton/: multi_button.c multi_button.h
    ../../middleware/SlateUI/port/: sl_port.c sl_port.h
  group middleware/easydmx
    ../../middleware/easyDMX/: easy_dmx.c easy_dmx.h
  group middleware/slateui/core
    ../../middleware/SlateUI/core/src/: sl_display.c sl_event.c sl_key_repeat.c sl_language.c sl_page_manager.c sl_page_registry.c sl_tween.c sl_ui.c
  group middleware/slateui/widgets
    ../../middleware/SlateUI/widgets/src/: sl_widget.c sl_label.c sl_list_view.c sl_linear_layout.c sl_horizontal_menu.c sl_icon.c sl_icon_item.c sl_progress_bar.c
  group middleware/slateui/menu
    ../../middleware/SlateUI/menu/src/: sl_menu_model.c sl_menu_page.c
  group middleware/slateui/font
    ../../middleware/SlateUI/font/: sl_font_ascii_16x16.c sl_font_ascii_16x16.h sl_font_chinese_16x16.c sl_font_chinese_16x16.h sl_font.h
